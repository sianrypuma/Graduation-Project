# Keil uVision project BiYeSheJi.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BiYeSheJi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER;.\CORE;.\STM32F10x_FWLib\inc;.\SYSTEM;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\SYSTEM\iic;.\SYSTEM\exti;.\HARDWARE\OLED;.\HARDWARE\DS18B20;.\HARDWARE\MAX30102;.\HARDWARE\BEEP;.\HARDWARE\PWM;.\HARDWARE\LED;.\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/DS18B20/: ds18b20.c
    ./HARDWARE/MAX30102/: max30102.c max30102_math.c
    ./HARDWARE/BEEP/: beep.c
    ./HARDWARE/LED/: led.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/iic/: iicStart.c
